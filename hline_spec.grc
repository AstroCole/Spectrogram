options:
  parameters:
    author: DCole
    description: Using core setup from DSPiRA Spectrometer
    generate_options: qt_gui
    id: hline_spec
    output_language: python
    title: Spectrometer
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: 1.4204058e9
  states: {}
- name: SDR_RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: (0,0,1,2)
    label: SDR RF Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
    widget: dial
  states: {}
- name: apply_cal
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: (8,0,1,1)
    initPressed: 'False'
    label: Apply Calibration File
    pressed: '1'
    released: '0'
    type: bool
    value: '0'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: hamming
  id: variable
  parameters:
    value: '1'
  states: {}
- name: integration_time_sec
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (6,0,1,1)
    label: Integration Time
    label0: 5 sec
    label1: 10 sec
    label2: 1 min
    label3: 5 min
    label4: 10 min
    num_opts: '5'
    option0: '5'
    option1: '10'
    option2: '60'
    option3: '300'
    option4: '600'
    type: int
    value: '5'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_loc/np.pi)
  states: {}
- name: sinc_loc
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2., np.pi*4/2., np.pi/vec_length)
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: write_cal
  id: variable_qtgui_push_button
  parameters:
    gui_hint: (7,0,1,1)
    label: Write Calibration File
    pressed: '1'
    released: '0'
    type: int
    value: '0'
  states: {}
- name: write_to_file
  id: variable_qtgui_toggle_button_msg
  parameters:
    gui_hint: (9,0,1,1)
    initPressed: 'False'
    label: Write Integration Files
    pressed: '1'
    released: '0'
    type: bool
    value: '1'
  states: {}
- name: y_max_cal
  id: variable_qtgui_entry
  parameters:
    gui_hint: (4,0,1,2)
    label: Y Max (Cal)
    type: real
    value: '2'
  states: {}
- name: y_max_raw
  id: variable_qtgui_entry
  parameters:
    gui_hint: (2,0,1,2)
    label: Y Max (Raw)
    type: real
    value: '2'
  states: {}
- name: y_min_cal
  id: variable_qtgui_entry
  parameters:
    gui_hint: (3,0,1,2)
    label: Y Min (Cal)
    type: real
    value: '-0.1'
  states: {}
- name: y_min_raw
  id: variable_qtgui_entry
  parameters:
    gui_hint: (1,0,1,2)
    label: Y Min (Raw)
    type: real
    value: '-0.1'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: vec_length*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: vec_length*3
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: my_h_line_tools_calibrator_0
  id: my_h_line_tools_calibrator
  parameters:
    apply_cal: apply_cal
    cal_path: h_line_cal.csv
    vector_size: vec_length
  states: {}
- name: my_h_line_tools_timed_vec_int_0
  id: my_h_line_tools_timed_vec_int
  parameters:
    cal_path: h_line_cal.csv
    integration_time_sec: integration_time_sec
    output_path: h_line_output.csv
    samp_rate: samp_rate
    vector_size: vec_length
    write_cal: write_cal
    write_to_file: write_to_file
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: (5,2,6,9)
    name: Post-Integration Spectrum
    vlen: vec_length
    x_axis_label: '"Frequency (Hz)"'
    x_start: Frequency - (samp_rate/2)
    x_step: samp_rate / vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    ymax: y_max_cal
    ymin: y_min_cal
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: (0,2,3,9)
    name: '"Post-FFT Spectrum"'
    vlen: vec_length
    x_axis_label: '"Frequency (Hz)"'
    x_start: Frequency - (samp_rate/2)
    x_step: samp_rate / vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    ymax: y_max_raw
    ymin: y_min_raw
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,bias=1
    bb_gain0: '10'
    freq0: Frequency
    gain0: SDR_RF_Gain
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_real_0, '0', my_h_line_tools_timed_vec_int_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [my_h_line_tools_calibrator_0, '0', qtgui_vector_sink_f_0, '0']
- [my_h_line_tools_timed_vec_int_0, '0', my_h_line_tools_calibrator_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0_1, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
