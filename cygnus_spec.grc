options:
  parameters:
    author: DCole
    description: Using core setup from DSPiRA Spectrometer
    generate_options: no_gui
    id: cygnus_spec
    output_language: python
    title: Spectrometer
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: 1.4204058e9
  states: {}
- name: SDR_RF_Gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: apply_cal
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: custom_window
  id: variable
  parameters:
    value: sinc*np.hamming(4*vec_length)
  states: {}
- name: hamming
  id: variable
  parameters:
    value: '1'
  states: {}
- name: integration_time_sec
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: sinc
  id: variable
  parameters:
    value: np.sinc(sinc_loc/np.pi)
  states: {}
- name: sinc_loc
  id: variable
  parameters:
    value: np.arange(-np.pi*4/2., np.pi*4/2., np.pi/vec_length)
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: write_cal
  id: variable
  parameters:
    value: '0'
  states: {}
- name: write_to_file
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: vec_length
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: vec_length*2
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: vec_length*3
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[-vec_length:]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[2*vec_length:3*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[vec_length:2*vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: custom_window[0:vec_length]
    type: complex
    vlen: vec_length
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_length
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: vec_length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(vec_length)
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: my_h_line_tools_calibrator_0
  id: my_h_line_tools_calibrator
  parameters:
    apply_cal: apply_cal
    cal_path: h_line_cal.csv
    vector_size: vec_length
  states: {}
- name: my_h_line_tools_timed_vec_int_0
  id: my_h_line_tools_timed_vec_int
  parameters:
    cal_path: h_line_cal.csv
    integration_time_sec: integration_time_sec
    output_path: h_line_output.csv
    samp_rate: samp_rate
    vector_size: vec_length
    write_cal: write_cal
    write_to_file: write_to_file
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: rtl=0,bias=1
    bb_gain0: '10'
    freq0: Frequency
    gain0: SDR_RF_Gain
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5678
    timeout: '100'
    type: float
    vlen: vec_length
  states: {}
- name: zeromq_pub_sink_0_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://*:5679
    timeout: '100'
    type: float
    vlen: vec_length
  states: {}

connections:
- [blocks_add_xx_0, '0', fft_vxx_0, '0']
- [blocks_complex_to_real_0, '0', my_h_line_tools_timed_vec_int_0, '0']
- [blocks_complex_to_real_0, '0', zeromq_pub_sink_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_delay_0_1, '0', blocks_stream_to_vector_0_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_stream_to_vector_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [fft_vxx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [my_h_line_tools_calibrator_0, '0', zeromq_pub_sink_0_0, '0']
- [my_h_line_tools_timed_vec_int_0, '0', my_h_line_tools_calibrator_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0_1, '0']
- [rtlsdr_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
