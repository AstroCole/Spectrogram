options:
  parameters:
    author: DCole
    description: 'Receiving spectrogram ZMQ PUB block data from cygnus (remote computer) '
    generate_options: qt_gui
    id: cygnus_gui
    output_language: python
    title: Cygnus Spectrometer GUI
  states: {}

blocks:
- name: Frequency
  id: variable
  parameters:
    value: 1.4204058e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: vec_length
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: y_max_cal
  id: variable_qtgui_entry
  parameters:
    gui_hint: (4,0,1,2)
    label: Y Max (Cal)
    type: real
    value: '2'
  states: {}
- name: y_max_raw
  id: variable_qtgui_entry
  parameters:
    gui_hint: (2,0,1,2)
    label: Y Max (Raw)
    type: real
    value: '2'
  states: {}
- name: y_min_cal
  id: variable_qtgui_entry
  parameters:
    gui_hint: (3,0,1,2)
    label: Y Min (Cal)
    type: real
    value: '-0.1'
  states: {}
- name: y_min_raw
  id: variable_qtgui_entry
  parameters:
    gui_hint: (1,0,1,2)
    label: Y Min (Raw)
    type: real
    value: '-0.1'
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: (5,2,6,9)
    name: Post-Integration Spectrum
    vlen: vec_length
    x_axis_label: '"Frequency (Hz)"'
    x_start: Frequency - (samp_rate/2)
    x_step: samp_rate / vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    ymax: y_max_cal
    ymin: y_min_cal
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    gui_hint: (0,2,3,9)
    name: '"Post-FFT Spectrum"'
    vlen: vec_length
    x_axis_label: '"Frequency (Hz)"'
    x_start: Frequency - (samp_rate/2)
    x_step: samp_rate / vec_length
    x_units: '"Hz"'
    y_axis_label: '"Signal"'
    ymax: y_max_raw
    ymin: y_min_raw
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.0.0.114:5679
    timeout: '100'
    type: float
    vlen: vec_length
  states: {}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://10.0.0.114:5678
    timeout: '100'
    type: float
    vlen: vec_length
  states: {}

connections:
- [zeromq_sub_source_0, '0', qtgui_vector_sink_f_0_0, '0']
- [zeromq_sub_source_0_0, '0', qtgui_vector_sink_f_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
